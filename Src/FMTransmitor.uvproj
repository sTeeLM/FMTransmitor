# Keil uVision project FMTransmitor.uvproj, settings and files
target Debug (MCS-51)
  device: STC8G1K17A STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x41FF) CLOCK(35000000)
  output: FMTransmitor_Debug +hex
  c flags: Optimize=8
  c define: __FM_TRANS_DEBUG__
  c include: .\state_machine
  group main
    ./: STARTUP.A51 clock.c com.c debug.c delay.c gpio.c i2c.c main.c power.c sm.c task.c tm1650.c kt0803.c eerom.c button.c
  group state_machine
    ./state_machine/: sm_trans_fm.c sm_trans_alc.c sm_trans_sd.c sm_trans_rf_gain.c sm_trans_ptc.c sm_trans_stereo.c sm_trans_bass.c sm_trans_fdd.c sm_trans_afre.c sm_trans_scm.c sm_trans_pta.c sm_trans_bright.c sm_trans_pa.c
